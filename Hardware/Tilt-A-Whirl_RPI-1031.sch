File: Hardware/Tilt-A-Whirl_RPI-1031.sch (EAGLE design)
At the start: 11 parts, among them U1 RPI-1031

Commit message: Updating board/schematic from review
Other:
- moved on the sheet: JP1, R3
